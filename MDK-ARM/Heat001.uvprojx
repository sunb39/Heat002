# Keil uVision project Heat001.uvprojx, settings and files
target Heat001 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Heat001 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../App;..\freemodbus-v1.6\modbus\functions;..\freemodbus-v1.6\modbus\include;..\freemodbus-v1.6\modbus\rtu;..\freemodbus-v1.6\demo\BARE\port
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group ModBus_Core
    D:/Modbus/freemodbus-v1.6/modbus/: mb.c
    D:/Modbus/freemodbus-v1.6/modbus/functions/: mbfuncholding.c mbutils.c
  group ModBus_RTU
    D:/Modbus/freemodbus-v1.6/modbus/rtu/: mbcrc.c mbrtu.c
  group ModBus_Port
    D:/Modbus/freemodbus-v1.6/demo/BARE/port/: portevent.c portserial.c porttimer.c
  group Application/User/App
    ../App/: modbus_regs.c modbus_regs.h param_store.c param_store.h m1820.c m1820.h
software components: CMSIS:CORE 4.3.0
